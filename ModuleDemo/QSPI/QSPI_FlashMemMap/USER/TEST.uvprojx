# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: TEST +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\mh22xxLib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM;..\SYSTEM\qspi_flash_test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c mh22xx_it.c
    ../../../../Libraries/mh22xxLib/src/: system_mh22xx.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_mh22xx.s
  group FWLib
    ../../../../Libraries/mh22xxLib/src/: misc.c mh22xx_adc.c mh22xx_gpio.c mh22xx_rcc.c mh22xx_tim.c mh22xx_dma.c mh22xx_usart.c mh22xx_flash.c mh22xx_qspi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group QSPIFLASHTEST
    ../SYSTEM/qspi_flash_test/: Flash_Info.c Flash_Test.c
