# Keil uVision project Project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\User;..\..\User\cryptlibTest;..\..\..\..\Libraries\mh22xxLib\inc;..\..\..\..\Libraries\mh22xxLib\inc\cryptlib;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\mh22xxLib\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --callgraph
  group User
    ../../User/: main.c mh22xx_it.c
  group MDK-ARM
    ../../../../Libraries/CORE/: startup_mh22xx.s
  group MHSCPU_Driver
    ../../../../Libraries/mh22xxLib/src/: misc.c mh22xx_gpio.c mh22xx_rcc.c mh22xx_tim.c mh22xx_usart.c mh22xx_trng.c
  group CMSIS
    ../../../../Libraries/mh22xxLib/src/: system_mh22xx.c
  group CRYPT_SELF_TEST
    ../../User/cryptlibTest/: debug.c mh_bignum_tool.c aes_self_test.c des_self_test.c sha_self_test.c sm3_self_test.c
  group CRYPT_LIB
    ../../../../Libraries/mh22xxLib/lib/: crypt_lib.lib
target RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,STM32F10X_HD
  c include: ..\..\..\..\Libraries\mhF103Lib\inc;..\..\..\..\Libraries\mhF103Lib\inc\cryptlib;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\STM32F10x_FWLib\inc;..\..\User\cryptlibTest;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --callgraph
software components: CMSIS:CORE 5.2.0
