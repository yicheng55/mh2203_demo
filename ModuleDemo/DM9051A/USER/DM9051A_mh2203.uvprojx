# Keil uVision project DM9051A_mh2203.uvprojx, settings and files
target DM9051A (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: DM9051A +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\bsp;..\..\..\Libraries\MH20xxLib\inc;..\..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c mh20xx_it.c main_uip_mh2030a.c
    ../../../Libraries/MH20xxLib/src/: system_mh20xx.c
  group BSP
    ../bsp/: dm9051a.c mh2030a_spi1.c mh2030a_spi1_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../Libraries/CORE/: startup_mh20xx.s
  group FWLib
    ../../../Libraries/MH20xxLib/src/: mh20xx_usart.c mh20xx_rcc.c mh20xx_gpio.c mh20xx_dma.c mh20xx_misc.c mh20xx_syscfg.c mh20xx_exti.c mh20xx_flash.c mh20xx_spi.c mh20xx_pwr.c mh20xx_crc.c mh20xx_adc.c mh20xx_comp.c mh20xx_i2c.c mh20xx_iwdg.c mh20xx_rtc.c mh20xx_tim.c mh20xx_wwdg.c mh20xx_dbgmcu.c
  group MH2030A_PORT
    ../port/mh2030a/: mh2030a_board.c mh2030a_dm9051_spi.c mh2030a_dm9051_int.c mh2030a_dm9051_spi_dma.c
    ../port/uip/: clock-arch.c netconf_mh2030a.c dm9051_uip_adapter.c
  group DM9051_CORE
    ../../../drivers/dm9051_edriver_v1.6.1a_beta/core/: dm9051_beta.c
  group uIP_CORE
    ../../../middlewares/3rd_party/uip/src/: uip.c uip_arp.c timer.c psock - EditA.c
  group uIP_APP
    ../../../apps/uip_dm9051_example_e1/uip_app_src/: uip-conf.c app_call.c
    ../../../apps/uip_dm9051_example_e1/uip_app_src/Eth_app/debug_app/: debug_app.c
    ../../../apps/uip_dm9051_example_e1/uip_app_src/Eth_app/resolv/: resolv.c
  group WEB_APP
    ../../../apps/uip_dm9051_example_e1/uip_app_src/webserver/src/DM/: httpd.c httpd-fs.c httpd-cgi-test1.c http-strings.c
target DM9051A_SPI_DMA (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: DM9051A_DMA +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MH2030A_DM9051_uIP (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: MH2030A_DM9051_uIP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,MH2030A_UIP_PORT
  c include: ..\SYSTEM\delay;..\USER;..\bsp;..\..\..\Libraries\MH20xxLib\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\middlewares\3rd_party\uip\inc;..\..\..\middlewares\3rd_party\uip\port\at32f415_dm9051;..\..\..\apps\uip_dm9051_example_e1\example_uip\inc;..\..\..\apps\uip_dm9051_example_e1\uip_conf_inc;..\..\..\apps\uip_dm9051_example_e1\uip_app_src;..\..\..\apps\uip_dm9051_example_e1\uip_app_src\Eth_app\dhcpc;..\..\..\apps\uip_dm9051_example_e1\uip_app_src\Eth_app\resolv;..\..\..\apps\uip_dm9051_example_e1\uip_app_src\webserver\inc;..\..\..\drivers\dm9051_edriver_v1.6.1a_beta;..\port\mh2030a;..\port\uip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MH2030A_DM9051_uIP_dma (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: MH2030A_DM9051_uIP_dma +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,MH2030A_UIP_PORT,MH2030A_DM9051_SPI_DMA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MH2030A_DM9051_uIP_int (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: MH2030A_DM9051_uIP_int +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,MH2030A_UIP_PORT,DMPLUG_INT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
