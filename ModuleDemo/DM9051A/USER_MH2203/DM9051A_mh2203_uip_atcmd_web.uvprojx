# Keil uVision project DM9051A_mh2203_uip_atcmd_web.uvprojx, settings and files
target MH2203_DM9051_uIP_ATCMD_WEB (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: DM9051A_mh2203_uip_atcmd_web +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,DM9051_UIP_PORT,DM9051_MH2203_DIAG=0,DM9051_TX_WAIT_DONE=1,DM9051_USE_DMA=1,DM9051_USE_IRQ=1,PRINTF_DEBUG_OUTPUT=1
  c include: ..\USER_MH2203;..\atcmd_web\compat\uip_mh2203;..\atcmd_web\port;..\atcmd_web\port\net_if;..\atcmd_web\app;..\atcmd_web\app\at_command;..\atcmd_web\app\etherbridge;..\atcmd_web\app\webserver;..\atcmd_web\net\uip\include;..\dm9051_driver\core\inc;..\dm9051_driver\hal\inc;..\dm9051_driver\adapters\uip;..\dm9051_driver\ports\mh2203;..\dm9051_driver\examples\uip_mh2203_demo;..\bsp;..\..\..\Libraries\MH22xxLib\inc;..\..\..\Libraries\CMSIS\Include
  asm define: USE_STDPERIPH_DRIVER,DM9051_UIP_PORT,DM9051_MH2203_DIAG=0,DM9051_TX_WAIT_DONE=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../../../Libraries/MH22xxLib/src/: system_mh22xx.c
    ../atcmd_web/app/: main_atcmd_web_mh2203.c
  group SYSTEM
    ../dm9051_driver/ports/mh2203/: delay.c
  group CORE
    ../../../Libraries/CORE/: startup_mh22xx.s
  group FWLib
    ../../../Libraries/MH22xxLib/src/: mh22xx_usart.c mh22xx_rcc.c mh22xx_gpio.c mh22xx_dma.c misc.c mh22xx_exti.c mh22xx_flash.c mh22xx_spi.c mh22xx_iwdg.c mh22xx_wwdg.c mh22xx_adc.c mh22xx_bkp.c mh22xx_can.c mh22xx_crc.c mh22xx_pwr.c mh22xx_tim.c
  group MH2203_PORT
    ../dm9051_driver/ports/mh2203/: mh2203_board.c dm9051_hal_mh2203_spi1.c dm9051_hal_mh2203_spi1_dma.c dm9051_hal_mh2203_int.c
  group DM9051_DRIVER_STAGING
    ../dm9051_driver/adapters/uip/: dm9051_uip.c
    ../dm9051_driver/examples/uip_mh2203_demo/: dm9051_uip_mh2203_demo.c
  group dm9051/core
    ../dm9051_driver/core/src/: dm9051_core.c dm9051_debug.c
  group ATCMD_WEB_PORT
    ../atcmd_web/port/: at_port.c clock-arch.c udp_printf.c
    ../atcmd_web/port/net_if/: tapdev.c
  group ATCMD_WEB_AT_COMMAND
    ../atcmd_web/app/at_command/: app_call.c atcommand.c at_base_cmd.c at_tcpip_cmd.c dataflash.c
  group ATCMD_WEB_ETHERBRIDGE
    ../atcmd_web/app/etherbridge/: etherbridge.c
  group ATCMD_WEB_WEBSERVER
    ../atcmd_web/app/webserver/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
  group ATCMD_WEB_UIP_CORE
    ../atcmd_web/net/uip/core/: uip.c uip_arp.c uip_init.c uip_keepalive.c uip_timer.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group ATCMD_WEB_UIP_APPS
    ../atcmd_web/net/uip/apps/: dhcpc.c resolv.c psock.c memb.c trans_level.c
