# Keil uVision project DM9051A_spipro_mh2203.uvprojx, settings and files
target DM9051A (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: DM9051A +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER_MH2203;..\bsp_mh2203;..\..\..\Libraries\MH22xxLib\inc;..\..\..\Libraries\CMSIS\Include;..\dm9051_driver\ports\mh2203
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../bsp_mh2203/: mh22xx_it.c
    ../../../Libraries/MH22xxLib/src/: system_mh22xx.c
    ./: main_spi_probe.c
  group BSP
    ../bsp_mh2203/: dm9051a.c mh2203_spi1.c mh2203_spi1_dma.c
  group SYSTEM
    ../dm9051_driver/ports/mh2203/: delay.c
  group CORE
    ../../../Libraries/CORE/: startup_mh22xx.s
  group FWLib
    ../../../Libraries/MH22xxLib/src/: mh22xx_usart.c mh22xx_rcc.c mh22xx_gpio.c mh22xx_dma.c misc.c mh22xx_exti.c mh22xx_flash.c mh22xx_spi.c mh22xx_pwr.c mh22xx_crc.c mh22xx_adc.c mh22xx_i2c.c mh22xx_iwdg.c mh22xx_rtc.c mh22xx_tim.c mh22xx_wwdg.c mh22xx_dbgmcu.c
  group DM9051_CORE
    ../../../drivers/dm9051_edriver_v1.6.1a_beta/core/: dm9051_beta.c
  group uIP_CORE
    ../../../middlewares/3rd_party/uip/src/: uip.c uip_arp.c timer.c psock - EditA.c
  group uIP_APP
    ../../../apps/uip_dm9051_example_e1/uip_app_src/: uip-conf.c app_call.c
    ../../../apps/uip_dm9051_example_e1/uip_app_src/Eth_app/debug_app/: debug_app.c
    ../../../apps/uip_dm9051_example_e1/uip_app_src/Eth_app/resolv/: resolv.c
  group WEB_APP
    ../../../apps/uip_dm9051_example_e1/uip_app_src/webserver/src/DM/: httpd.c httpd-fs.c httpd-cgi-test1.c http-strings.c
target DM9051A_SPI_DMA (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: DM9051A_DMA +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MH2030A_DM9051_uIP (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: MH2030A_DM9051_uIP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,DM9051_UIP_PORT
  c include: ..\SYSTEM\delay;..\USER_MH2203;..\bsp_mh2203;..\..\..\Libraries\MH22xxLib\inc;..\..\..\Libraries\CMSIS\Include;..\dm9051_driver\ports\mh2203;..\..\..\middlewares\3rd_party\uip\inc;..\..\..\middlewares\3rd_party\uip\port\at32f415_dm9051;..\..\..\apps\uip_dm9051_example_e1\example_uip\inc;..\..\..\apps\uip_dm9051_example_e1\uip_conf_inc;..\..\..\apps\uip_dm9051_example_e1\uip_app_src;..\..\..\apps\uip_dm9051_example_e1\uip_app_src\Eth_app\dhcpc;..\..\..\apps\uip_dm9051_example_e1\uip_app_src\Eth_app\resolv;..\..\..\apps\uip_dm9051_example_e1\uip_app_src\webserver\inc;..\..\..\drivers\dm9051_edriver_v1.6.1a_beta;..\bsp_mh2203;..\port\uip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MH2030A_DM9051_uIP_dma (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: MH2030A_DM9051_uIP_dma +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,DM9051_UIP_PORT,DM9051_SPI_DMA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MH2030A_DM9051_uIP_int (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: as above
  output: MH2030A_DM9051_uIP_int +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,DM9051_UIP_PORT,DMPLUG_INT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
