# Keil uVision project GPIO.uvprojx, settings and files
target GPIO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: v6Lang=1 v6LangP=1
  c define: mh210x_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\mh22xxLib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0xc000
  scatter file: ..\OBJ\GPIO.sct
  group USER
    ./: main.c mh22xx_it.c
    ../../../../Libraries/MH2203Lib/src/: system_mh22xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_mh22xx.s
  group FWLib
    ../../../../Libraries/mh22xxLib/src/: misc.c mh22xx_rcc.c mh22xx_gpio.c mh22xx_usart.c mh22xx_exti.c mh22xx_flash.c
