# Keil uVision project RCC.uvprojx, settings and files
target RCC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RCC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\mh22xxLib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM;..\..\..\..\Libraries\mh210xLib\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c mh22xx_it.c
    ../../../../Libraries/mh22xxLib/src/: system_mh22xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_mh22xx.s
  group FWLib
    ../../../../Libraries/mh22xxLib/src/: misc.c mh22xx_rcc.c mh22xx_gpio.c mh22xx_usart.c mh22xx_flash.c
