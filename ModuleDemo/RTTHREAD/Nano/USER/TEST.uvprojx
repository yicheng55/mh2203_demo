# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,RTE_USING_FINSH
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\mh22xxLib\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\CMSIS\Lib\ARM;..\..\..\..\Libraries\mh22xxLib\lib;..\rt-thread\include\libc;..\rt-thread\include;..\rt-thread\bsp;..\rt-thread\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c mh22xx_it.c
    ../rt-thread/bsp/: board.c
    ../../../../Libraries/MH22xxLib/src/: system_mh22xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_mh22xx.s
  group FWLib
    ../../../../Libraries/MH22xxLib/src/: mh22xx_rcc.c mh22xx_usart.c misc.c mh22xx_gpio.c mh22xx_flash.c
  group RTT/SOURCE
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RTT/PORT
    ../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group RTT/FINSH
    ../rt-thread/components/finsh/: cmd.c finsh_port.c msh.c shell.c
