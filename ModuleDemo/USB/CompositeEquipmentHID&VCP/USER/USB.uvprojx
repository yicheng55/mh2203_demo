# Keil uVision project USB.uvprojx, settings and files
target USB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\Libraries\mh22xxLib\inc;..\SYSTEM\led;..\SYSTEM\delay;..\USER;..\USB\CONFIG;..\USB\USB-FS-Device_Driver\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\mh22xxLib\lib;..\..\..\..\ModuleDemo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ./: main.c mh22xx_it.c
    ../SYSTEM/delay/: delay.c
  group Startup
    ../../../../Libraries/CORE/: startup_mh22xx.s
  group StdPeriph_Driver
    ../../../../Libraries/mh22xxLib/src/: mh22xx_gpio.c mh22xx_rcc.c mh22xx_exti.c mh22xx_tim.c mh22xx_usart.c mh22xx_iwdg.c mh22xx_wwdg.c mh22xx_bkp.c mh22xx_pwr.c mh22xx_adc.c mh22xx_dac.c mh22xx_dma.c mh22xx_rtc.c mh22xx_can.c misc.c mh22xx_flash.c
  group CMSIS
    ../../../../Libraries/CORE/: core_cm3.c
    ../../../../Libraries/mh22xxLib/src/: system_mh22xx.c
  group USB_CORE
    ../USB/USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c loop_buf.c
