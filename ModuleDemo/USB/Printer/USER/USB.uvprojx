# Keil uVision project USB.uvprojx, settings and files
target USB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: USB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\Libraries\mh210xLib\inc;..\SYSTEM\led;..\SYSTEM\delay;..\USER;..\USB\CONFIG;..\USB\USB-FS-Device_Driver\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CORE;..\..\..\..\Libraries\MH22xxLib\inc;..\..\..\..\ModuleDemo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c mh22xx_it.c
    ../SYSTEM/delay/: delay.c
  group Startup
    ../../../../Libraries/CORE/: startup_mh22xx.s
  group StdPeriph_Driver
    ../../../../Libraries/MH22xxLib/src/: mh22xx_adc.c mh22xx_bkp.c mh22xx_can.c mh22xx_crc.c mh22xx_dac.c mh22xx_dbgmcu.c mh22xx_dma.c mh22xx_exti.c mh22xx_flash.c mh22xx_fsmc.c mh22xx_gpio.c mh22xx_i2c.c mh22xx_iwdg.c mh22xx_otp.c mh22xx_pwr.c mh22xx_qspi.c mh22xx_rcc.c mh22xx_rtc.c mh22xx_sdio.c mh22xx_spi.c mh22xx_tim.c mh22xx_trng.c mh22xx_usart.c mh22xx_wwdg.c misc.c system_mh22xx.c
  group CMSIS
    ../../../../Libraries/CORE/: core_cm3.c
  group USB_CORE
    ../USB/USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
