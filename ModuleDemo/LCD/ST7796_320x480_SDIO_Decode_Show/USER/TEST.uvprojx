# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SDIO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\SYSTEM\sdio;..\SYSTEM\fatfs;..\SYSTEM\decode;..\SYSTEM\font;..\SYSTEM\lcd;..\SYSTEM\malloc;..\..\..\..\Libraries\MH22xxLib\inc;..\..\..\..\Libraries\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c mh210x_it.c
    ../../../../Libraries/MH22xxLib/src/: system_mh22xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sdio/: bsp_sdio_sdcard.c sdio_test.c
    ../SYSTEM/lcd/: bsp_st7796_lcd.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_mh22xx.s
  group FWLib
    ../../../../Libraries/MH22xxLib/src/: mh22xx_usart.c misc.c mh22xx_rcc.c mh22xx_gpio.c mh22xx_fsmc.c mh22xx_dma.c mh22xx_flash.c mh22xx_sdio.c
  group FATFS
    ../SYSTEM/fatfs/: ff.c diskio.c exfuns.c fattester.c
    ../SYSTEM/fatfs/option/: cc936.c
  group DECODE
    ../SYSTEM/decode/: bmp.c gif.c piclib.c tjpgd.c
  group TFTLCD
    ../SYSTEM/font/: fonts.c
  group MALLOC
    ../SYSTEM/malloc/: malloc.c
