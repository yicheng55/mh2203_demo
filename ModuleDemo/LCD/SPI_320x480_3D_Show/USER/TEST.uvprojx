# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\SYSTEM\font;..\SYSTEM\lcd;..\SYSTEM\3d_test;..\SYSTEM\SPI_INIT;..\..\..\..\Libraries\MH22xxLib\inc;..\..\..\..\Libraries\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f400
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c mh2203_it.c
    ../SYSTEM/font/: fonts.c
    ../SYSTEM/3d_test/: 3DTest.c
    ../SYSTEM/SPI_INIT/: Spi_Base.c
    ../../../../Libraries/MH22xxLib/src/: system_mh22xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../../Libraries/CORE/: core_cm3.c startup_mh22xx.s
  group FWLib
    ../../../../Libraries/MH22xxLib/src/: mh22xx_dma.c mh22xx_flash.c mh22xx_gpio.c mh22xx_spi.c mh22xx_tim.c misc.c mh22xx_usart.c mh22xx_rcc.c
